# Keil uVision project stm32g0_single_slot_app.uvprojx, settings and files
target stm32g0_single_slot_app (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32G0B1RCTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x800A000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g0_single_slot_app +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Core/Inc;../../boot/Drivers/STM32G0xx_HAL_Driver/Inc;../../boot/Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../../boot/Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../boot/Drivers/CMSIS/Include;../USB_Device/App;../USB_Device/Target;../../boot/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../boot/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../port;../../../../smota;../../../../smota/smota_core/inc
  asm define: USE_HAL_DRIVER,STM32G0B1xx
  asm include: as above
  memory RVCT4: ROM 0x800a000 size 0x36000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: stm32g0_single_slot_app.sct
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/app/: main_app.c
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../boot/Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_ll_usb.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Middlewares/USB_Device_Library
    ../../boot/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../boot/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
